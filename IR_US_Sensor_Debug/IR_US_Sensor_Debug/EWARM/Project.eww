<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\IR_US_Sensor_Debug.ewp</path>
  </project>
  <batchBuild />
</workspace>
